# Keil uVision project EXTI.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 1dayu +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\User\led;..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User\exti;..\User\dht11;..\User\systick;..\User\oled;..\User\tim;..\User\bh1750;..\User\motor;..\User\key;..\..\Key\User\systick;..\User\fun;..\NET\cJSON;..\NET\device;..\NET\MQTT;..\NET\onenet;..\User\sys;..\User\BEEP;..\User\usart;..\User\TIMER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/led/: main.c stm32f10x_it.c led.c
    ../User/exti/: bsp_exti.c
    ../User/systick/: bsp_systick.c
    ../User/oled/: OLED_I2C.c delay.c
    ../User/motor/: bsp_motor.c
    ../User/key/: bsp_key.c
    ../User/fun/: fun.c
    ../User/usart/: usart.c
    ../User/bh1750/: bh1750.c
    ../User/dht11/: dht11.c
    ../User/sys/: sys.c
    ../User/BEEP/: beep.c
    ../User/tim/: bsp_tim.c
  group NET
    ../NET/onenet/: onenet.c
    ../NET/MQTT/: MqttKit.c
    ../NET/device/: esp8266.c
    ../NET/cJSON/: cJSON.c
